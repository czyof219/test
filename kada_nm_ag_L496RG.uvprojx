# Keil uVision project kada_nm_ag_L496RG.uvprojx, settings and files
target kada_nm_ag (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L496RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: kada_nm_ag +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L496xx,HSE_VALUE=16000000
  c include: .\BSP;.\dbguart;.\OP;.\STemWin_Library_V1.2.0\Libraries\STemWinLibrary532\Config;.\STemWin_Library_V1.2.0\Libraries\STemWinLibrary532\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./doc/: ver.txt
    ./: main.c ThreadOled.c ThreadKey.c ThreadWiFi.c ThreadAg.c ThreadRtc.c ThreadLed.c ThreadVbat.c ThreadMx25_PSRAM.c
  group BSP
    ./BSP/: bsp.h buzz.c leds.c oled.c tim5.c psram.c ads1220.c dac.c chgBat.c drv595.c drv595.h chgBat.h rtc.c MX25L256.c AdcVol.c delayus.c vect_rst.c shuaji.c
  group dbgUart
    ./dbguart/: dbgUart.c debug_cmd_parse.c UartRxBuf.c uartxx.c
  group STemWin/lib
    ./STemWin_Library_V1.2.0/Libraries/STemWinLibrary532/Lib/: STemWin532_CM4_Keil.lib
  group STemWin/config
    ./STemWin_Library_V1.2.0/Libraries/STemWinLibrary532/Config/: GUIConf.c LCDConf_Lin_Template.c
    ./STemWin_Library_V1.2.0/Libraries/STemWinLibrary532/OS/: GUI_X.c
  group STemWin/fonts
    ./fonts/: shengjichongq.c
  group STemwin/bmp
    ./STemWin_Library_V1.2.0/Libraries/STemWinLibrary532/: logo_wifi.c logo_wifi4.c wifi_12_12.c wifi_12_12_no.c
  group OP
    ./OP/: op.c
  group utility
    ./utility/: crc32.c
target boot2_08008000 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L496RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.3.0
  cpu: as above
  output: boot2_L496RG +hex
  AfterMake: .\tobin.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L496xx,HSE_VALUE=16000000,VECT_TAB_OFFSET=0x8000
  c include: as above
  memory RVCT4: ROM 0x8008000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.1.2, CMSIS:RTOS2:Keil RTX5 5.4.0, Device:Startup 1.3.1
